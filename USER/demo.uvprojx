# Keil uVision project demo.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ./: main.c
  group Hardware
    ../HARDWARE/: SystemClock.c Nvic.c Usart.c Delay.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
